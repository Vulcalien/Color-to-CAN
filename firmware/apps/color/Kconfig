## firmware/apps/color/Kconfig
```kconfig
config CUSTOM_COLOR_APP
    tristate "Color sensor app"
    default y
    ---help---
        Color sensor application
```
